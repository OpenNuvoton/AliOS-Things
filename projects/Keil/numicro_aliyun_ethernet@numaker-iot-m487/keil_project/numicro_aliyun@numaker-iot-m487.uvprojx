# Keil uVision project numicro_aliyun@numaker-iot-m487.uvprojx, settings and files
target numicro_aliyun@numaker-iot-m487 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: numicro_aliyun@numaker-iot-m487
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BUILD_BIN,NUMICRO_M487,STDIO_UART=0,STDIO_UART_BUADRATE=115200,CLI_CONFIG_SUPPORT_BOARD_CMD=1,KV_CONFIG_PARTITION=5,WITH_LWIP,LWIP_MAILBOX_QUEUE,LWIP_TIMEVAL_PRIVATE=0,BUILD_AOS,CONFIG_HTTP_AUTH_TIMEOUT=500,CONFIG_MID_HTTP_TIMEOUT=500,CONFIG_GUIDER_AUTH_TIMEOUT=500,WITH_MQTT_ZIP_TOPIC=1,WITH_MQTT_SUB_SHORTCUT=1,WITH_MQTT_DYN_BUF=1,COAP_SERV_MULTITHREAD,NET_WITH_WIFI,AOS_NETMGR,AOS_COMP_CLI,CONFIG_NET_LWIP,AOS_LOOP,AOS_COMP_KV,OSAL_RHINO,AOS_HAL,AOS_COMP_ULOG,AOS_COMP_DEBUG,AOS_COMP_RHINO,__BSD_VISIBLE,AOS_COMP_VFS
  c misc: -DSYSINFO_OS_VERSION="100" -DSYSINFO_PRODUCT_MODEL="ALI_AOS_NUMAKER_M487" -DSYSINFO_DEVICE_NAME="board_numaker-iot-m487" -DSYSINFO_ARCH="Cortex-M4" -DSYSINFO_MCU="mcu_m487jidae" -D_IS_LINKKIT_ -DFORCE_SSL_VERIFY -DCOAP_OBSERVE_SERVER_SUPPORTED -DCOAP_OBSERVE_CLIENT_SUPPORTED -DCOAP_SERV_MULTITHREAD -DCOAP_USE_PLATFORM_MEMORY -DCOAP_USE_PLATFORM_LOG --c99 --cpu=Cortex-M4 --apcs=/hardfp --fpu=vfpv4_sp_d16 -D__MICROLIB -g --split_sections
  c include: ../../../../app/example/numicro_aliyun/;../../../../board/numaker-iot-m487/.;../../../../board/numaker-iot-m487/config/;../../../../board/numaker-iot-m487/drivers/;../../../../board/numaker-iot-m487/startup/;../../../../middleware/linkkit/sdk-c/include/exports;../../../../middleware/linkkit/sdk-c/include/imports;../../../../middleware/linkkit/sdk-c/include;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/sdk-impl;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/infra/utils/digest;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/infra/utils;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/infra/utils/misc;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/infra/log;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/infra/system;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/include/exports;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/include/imports;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/include;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/protocol/alcs;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/protocol/coap/server;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/linkkit/dev_reset;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/dev_bind;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/dev_bind/utility;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/awss;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/linkkit/dm;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/linkkit/cm;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/mdal/mal;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/ota;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/services/ota/impl;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/utils/misc;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/protocol/mqtt;../../../../middleware/linkkit/sdk-c/...middleware/linkkit/sdk-c/src/protocol/mqtt/client;../../../../network/netmgr/include;../../../../utility/cjson/include;../../../../kernel/cli/include;../../../../platform/mcu/m487jidae/drivers/lwIP/include/netif;../../../../platform/mcu/m487jidae/drivers/lwIP/include;../../../../platform/mcu/m487jidae/drivers/Library/CMSIS/Include;../../../../platform/mcu/m487jidae/drivers/Library/Device/Nuvoton/M480/Include;../../../../platform/mcu/m487jidae/drivers/Library/StdDriver/inc;../../../../platform/mcu/m487jidae/drivers/misc;../../../../platform/mcu/m487jidae/drivers/common;../../../../platform/mcu/m487jidae/...drivers/sal/wifi/esp8266_aos;../../../../utility/libc/compilers/armlibc;../../../../kernel/init/include;../../../../network/lwip/include;../../../../network/lwip/port/include;../../../../network/yloop/include;../../../../network/yloop/hal;../../../../kernel/fs/kv/.;../../../../kernel/fs/kv/include;../../../../osal/aos/.;../../../../middleware/uagent/ulog/include;../../../../kernel/debug/;../../../../kernel/debug/include;../../../../platform/arch/arm/armv7m/common/;../../../../kernel/rhino/include;../../../../kernel/rhino/;../../../../kernel/fs/vfs/.;../../../../kernel/fs/vfs/include;../../../../utility/activation/.;../../../../utility/activation/chip_code/.;../../../../security/alicrypto/.include/icrypto;../../../../security/mbedtls/.include;../../../../security/ls_osa/.include/osa;../../../../include;../../../../include/hal;../../../../include/hal/soc;../../../../include/network
  asm misc: --cpu=Cortex-M4 -g --apcs=/hardfp --fpu=vfpv4_sp_d16 --library_type=microlib --pd "__MICROLIB SETA 1" --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: ../../../../board/numaker-iot-m487/M487.sct
  link misc: --cpu=Cortex-M4 --fpu=vfpv4_sp_d16 --apcs=/hardfp --strict --xref --callgraph --symbols --info=sizes --info=totals --info=unused --info=veneers --info=summarysizes
  group numicro_aliyun
    ../../../.././app/example/numicro_aliyun/: app_entry.c mqtt_example.c numicro_m487_led_button.c
  group board_numaker-iot-m487
    ../../../.././board/numaker-iot-m487/config/: k_config.c partition_conf.c
    ../../../.././board/numaker-iot-m487/drivers/: ethernetif.c
    ../../../.././board/numaker-iot-m487/startup/: board.c board_cli.c startup.c startup_M480_gcc.c
  group netmgr
    ../../../.././network/netmgr/hal/: wifi.c
    ../../../.././network/netmgr/interfaces/: netmgr_wifi.c
    ../../../.././network/netmgr/: netmgr.c
  group cjson
    ../../../.././utility/cjson/: cJSON.c cJSON_Utils.c
  group cli
    ../../../.././kernel/cli/: cli.c cli_adapt.c cli_default_command.c cli_dumpsys.c
  group mcu_m487jidae
    ../../../.././platform/mcu/m487jidae/drivers/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../.././platform/mcu/m487jidae/drivers/Library/StdDriver/src/: clk.c crypto.c dac.c eadc.c epwm.c fmc.c gpio.c i2c.c pdma.c qspi.c retarget.c rtc.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c uart.c wdt.c
    ../../../.././platform/mcu/m487jidae/drivers/common/: CheckSumUtils.c PeripheralPins.c pinmap.c pinmap_common.c
    ../../../.././platform/mcu/m487jidae/drivers/lwIP/netif/: m480_eth.c
    ../../../.././platform/mcu/m487jidae/drivers/misc/: nu_modutil.c nu_rbuf.c
    ../../../.././platform/mcu/m487jidae/hal/: eth_port.c hal_adc.c hal_dac.c hal_dma.c hal_flash.c hal_gpio.c hal_i2c.c hal_interrupt.c hal_pwm.c hal_qspi.c hal_rng.c hal_rtc.c hal_sd.c hal_spi.c hal_timer.c hal_uart.c hal_wdg.c hw.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group lwip
    ../../../.././network/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../.././network/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../.././network/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../.././network/lwip/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../.././network/lwip/netif/: ethernet.c slipif.c
    ../../../.././network/lwip/port/: sys_arch.c
  group yloop
    ../../../.././network/yloop/hal/: loop_hal_alios.c
    ../../../.././network/yloop/src/: device.c local_event.c select.c workqueue.c yloop.c
  group iotx-hal
    ../../../.././middleware/linkkit/sdk-c/src/ref-impl/hal/os/alios/: HAL_Crypt_rhino.c HAL_OS_rhino.c HAL_PRODUCT_rhino.c HAL_TCP_rhino.c HAL_TLS_mbedtls.c HAL_UDP_rhino.c
  group libiot_mqtt
    ../../../.././middleware/linkkit/sdk-c/src/protocol/mqtt/./MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ../../../.././middleware/linkkit/sdk-c/src/protocol/mqtt/./client/: mqtt_client.c
  group kv
    ../../../.././kernel/fs/kv/: kv.c kv_adapt.c kv_cli.c
  group osal_aos
    ../../../.././osal/aos/: cli.c common.c kv.c rhino.c vfs.c
  group ulog
    ../../../.././middleware/uagent/ulog/: log.c ulog_init.c
  group debug
    ../../../.././kernel/debug/: debug_backtrace.c debug_cpuusage.c debug_infoget.c debug_overview.c debug_panic.c
  group arch_armv7m
    ../../../.././platform/arch/arm/armv7m/armcc/m4/: port_s.S
    ../../../.././platform/arch/arm/armv7m/common/: panic_armcc.S panic_c.c port_c.c
  group rhino
    ../../../.././kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group vfs
    ../../../.././kernel/fs/vfs/: vfs.c vfs_adapt.c vfs_file.c vfs_inode.c
  group activation
    ../../../.././utility/activation/: activation.c
  group chip_code
    ../../../.././utility/activation/chip_code/: chip_code.c
  group alicrypto
    ../../../.././security/alicrypto/./api/src/: api_aes.c api_hash.c api_hmac.c api_init.c api_rand.c api_rsa.c api_sm2.c api_sm4.c
    ../../../.././security/alicrypto/./core/src/: aes.c asn1parse.c bignum.c ecp.c ecp_curves.c hash_wrap.c hmac.c md5.c oid.c rsa.c sha1.c sha256.c sm2.c sm3.c sm4.c
    ../../../.././security/alicrypto/./sal/src/: sal_aes.c sal_hash.c sal_hmac.c sal_rand.c sal_rsa.c sal_sm2.c sal_sm4.c
  group imbedtls
    ../../../.././security/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c mbedtls_alt.c mbedtls_net.c mbedtls_ssl.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libiot_utils
    ../../../.././middleware/linkkit/sdk-c/src/infra/utils/./digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c utils_sha256.c
    ../../../.././middleware/linkkit/sdk-c/src/infra/utils/./misc/: json_parser.c json_token.c lite-cjson.c mem_stats.c utils_epoch_time.c utils_event.c utils_httpc.c utils_net.c utils_string.c utils_timer.c
  group libiot_log
    ../../../.././middleware/linkkit/sdk-c/src/infra/log/./: iotx_log.c
  group libiot_system
    ../../../.././middleware/linkkit/sdk-c/src/infra/system/./: ca.c event.c guider.c report.c
    ../../../.././middleware/linkkit/sdk-c/src/infra/system/./facility/: fac_string.c
  group libiot_sdk_impl
    ../../../.././middleware/linkkit/sdk-c/src/sdk-impl/./deprecated_linkkit/: impl_gateway.c impl_ntp.c impl_solo.c
    ../../../.././middleware/linkkit/sdk-c/src/sdk-impl/./: impl_dynreg.c impl_linkkit.c impl_logpost.c sdk-impl.c
  group ls_osa
    ../../../.././security/ls_osa//src/: ls_osa.c

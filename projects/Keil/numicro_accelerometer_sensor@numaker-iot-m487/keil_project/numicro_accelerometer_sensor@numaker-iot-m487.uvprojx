# Keil uVision project numicro_accelerometer_sensor@numaker-iot-m487.uvprojx, settings and files
target numicro_accelerometer_sensor@numaker-iot-m487 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: numicro_accelerometer_sensor@numaker-iot-m487
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BUILD_BIN,AOS_NO_WIFI,NUMICRO_M487,STDIO_UART=0,STDIO_UART_BUADRATE=115200,CLI_CONFIG_SUPPORT_BOARD_CMD=1,KV_CONFIG_PARTITION=5,CONFIG_NO_TCPIP,AOS_LOOP,NET_WITH_WIFI,AOS_NETMGR,__BSD_VISIBLE,AOS_COMP_VFS,AOS_COMP_RHINO,AOS_COMP_ULOG,AOS_COMP_KV,OSAL_RHINO,AOS_HAL,AOS_COMP_DEBUG,MCU_FAMILY="mcu_m487jidae"
  c misc: -DSYSINFO_OS_VERSION="100" -DSYSINFO_PRODUCT_MODEL="ALI_AOS_NUMAKER_M487" -DSYSINFO_DEVICE_NAME="board_numaker-iot-m487" -DSYSINFO_ARCH="Cortex-M4" -DSYSINFO_MCU="mcu_m487jidae" --c99 --cpu=Cortex-M4 --apcs=/hardfp --fpu=vfpv4_sp_d16 -D__MICROLIB -g --split_sections
  c include: ../../../../board/numaker-iot-m487/.;../../../../board/numaker-iot-m487/config/;../../../../board/numaker-iot-m487/drivers/;../../../../board/numaker-iot-m487/startup/;../../../../network/yloop/include;../../../../network/yloop/hal;../../../../platform/mcu/m487jidae/drivers/lwIP/include/netif;../../../../platform/mcu/m487jidae/drivers/lwIP/include;../../../../platform/mcu/m487jidae/drivers/Library/CMSIS/Include;../../../../platform/mcu/m487jidae/drivers/Library/Device/Nuvoton/M480/Include;../../../../platform/mcu/m487jidae/drivers/Library/StdDriver/inc;../../../../platform/mcu/m487jidae/drivers/misc;../../../../platform/mcu/m487jidae/drivers/common;../../../../platform/mcu/m487jidae/...drivers/sal/wifi/esp8266_aos;../../../../utility/libc/compilers/armlibc;../../../../kernel/init/include;../../../../network/netmgr/include;../../../../kernel/fs/vfs/.;../../../../kernel/fs/vfs/include;../../../../platform/arch/arm/armv7m/common/;../../../../kernel/rhino/include;../../../../kernel/rhino/;../../../../middleware/uagent/ulog/include;../../../../kernel/fs/kv/.;../../../../kernel/fs/kv/include;../../../../osal/aos/.;../../../../kernel/debug/;../../../../kernel/debug/include;../../../../include;../../../../include/hal;../../../../include/hal/soc;../../../../include/network
  asm misc: --cpu=Cortex-M4 -g --apcs=/hardfp --fpu=vfpv4_sp_d16 --library_type=microlib --pd "__MICROLIB SETA 1" --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: ../../../../board/numaker-iot-m487/M487.sct
  link misc: --cpu=Cortex-M4 --fpu=vfpv4_sp_d16 --apcs=/hardfp --strict --xref --callgraph --symbols --info=sizes --info=totals --info=unused --info=veneers --info=summarysizes
  group numicro_accelerometer_sensor
    ../../../.././app/example/numicro_accelerometer_sensor/BMX055/BMA2x2_driver/: bma2x2.c
    ../../../.././app/example/numicro_accelerometer_sensor/BMX055/BMG160_driver/: bmg160.c
    ../../../.././app/example/numicro_accelerometer_sensor/BMX055/BMM050_driver/: bmm050.c
    ../../../.././app/example/numicro_accelerometer_sensor/: numicro_m487.c
  group board_numaker-iot-m487
    ../../../.././board/numaker-iot-m487/config/: k_config.c partition_conf.c
    ../../../.././board/numaker-iot-m487/startup/: board.c board_cli.c startup.c startup_M480_gcc.c
  group yloop
    ../../../.././network/yloop/hal/: loop_hal_alios.c
    ../../../.././network/yloop/src/: device.c local_event.c select.c workqueue.c yloop.c
  group mcu_m487jidae
    ../../../.././platform/mcu/m487jidae/drivers/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../.././platform/mcu/m487jidae/drivers/Library/StdDriver/src/: clk.c crypto.c dac.c eadc.c epwm.c fmc.c gpio.c i2c.c pdma.c qspi.c retarget.c rtc.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c uart.c wdt.c
    ../../../.././platform/mcu/m487jidae/drivers/common/: CheckSumUtils.c PeripheralPins.c pinmap.c pinmap_common.c
    ../../../.././platform/mcu/m487jidae/drivers/misc/: nu_modutil.c nu_rbuf.c
    ../../../.././platform/mcu/m487jidae/hal/: hal_adc.c hal_dac.c hal_dma.c hal_flash.c hal_gpio.c hal_i2c.c hal_interrupt.c hal_pwm.c hal_qspi.c hal_rng.c hal_rtc.c hal_sd.c hal_spi.c hal_timer.c hal_uart.c hal_wdg.c hw.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group netmgr
    ../../../.././network/netmgr/hal/: wifi.c
    ../../../.././network/netmgr/interfaces/: netmgr_wifi.c
    ../../../.././network/netmgr/: netmgr.c
  group vfs
    ../../../.././kernel/fs/vfs/: vfs.c vfs_adapt.c vfs_file.c vfs_inode.c
  group arch_armv7m
    ../../../.././platform/arch/arm/armv7m/armcc/m4/: port_s.S
    ../../../.././platform/arch/arm/armv7m/common/: panic_armcc.S panic_c.c port_c.c
  group rhino
    ../../../.././kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group ulog
    ../../../.././middleware/uagent/ulog/: log.c ulog_init.c
  group kv
    ../../../.././kernel/fs/kv/: kv.c kv_adapt.c kv_cli.c
  group osal_aos
    ../../../.././osal/aos/: common.c kv.c rhino.c vfs.c
  group debug
    ../../../.././kernel/debug/: debug_backtrace.c debug_cpuusage.c debug_infoget.c debug_overview.c debug_panic.c
